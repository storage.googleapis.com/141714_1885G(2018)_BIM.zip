Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-10T15:56:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 10 15:56:27 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{8606BD08-4A9E-4581-A197-CB421422002F}\ifc * Database version: 5507 * Database creation date: Mon Jun 10 15:56:26 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 10 15:56:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 10 15:56:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1885G Shower faucet, 1885G(2018):1885G Shower faucet:353499
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 188.249 mm; NominalHeight: 128.525 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1885G(2018); ConvergoRefNr: 0087-1906-0022-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 07/06/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HB; Customs Code: 84818011; EAN Number: 6414150089718; EN Standard: EN 817; LVI Number: 6310857; Noise Class: I (ISO 3822); RSK Number: 8296241
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1885G; Catalog Drawing URL: http://static.oras.com/catdrw/1885G; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1885G; FDV Document URL: http://www.oras.com/datasheet/1885G/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1885G; Group: Shower faucets; Long Marketing: Shower faucet, 160cc. Shower hose connection G1/2. Lever is equipped with an eco-button for limiting water temperature and flow-rate, which can be bypassed by pressing the button; Manufacturer: Oras; Model: 1885G Shower faucet; Name_en: 1885G Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 200 x 165 x 95; Package Weight: 1.27 kg; Product Code: 1885G; Product Datasheet: http://www.oras.com/datasheet/1885G/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1885G; Product URL: http://static.oras.com/1885G; Type Name: 1885G Shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: M26x1.5; Eco Flow At 300kPa: 0.00565035 m3/s; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa: 0.00918181 m3/s; HWFU: 0; Installation and Maintenance: http://static.oras.com/manual/1885G; Installation Type: Wall mounted; Installation Width: 160 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 175000 Pa; Spare Parts: http://static.oras.com/sp/1885G
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1885G(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1885G; Name: 1885G Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 190x190x130 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1885G; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1885G Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0867013 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 160 mm; OutletAngle: 0 deg; Volume: 0.00463356 m3
Identity Data - Mark: 15
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1885G(2018): 1885G Shower faucet; Family and Type: 1885G(2018): 1885G Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1885G(2018): 1885G Shower faucet; Type Id: 1885G(2018): 1885G Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
